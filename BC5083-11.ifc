Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-02-12T01:25:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Feb 12 01:25:42 2023 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\1cb9ba69-09ad-46a9-bc81-9cccaa89f73d\952bf6e5-f752-4984-a8eb-c49fd67aac9e\ifc * Database version: 5507 * Database creation date: Sun Feb 12 01:25:42 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Feb 12 01:25:42 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Feb 12 01:25:42 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: BC5083-11, BC5083-11:BC5083-11:349320
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 1200 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rails; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-11; ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalLength: 1200 mm; NominalWidth: 1200 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-corner-shower-rail/; ReplacementCost: n/a; Size: 1200x1200; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-11; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-11
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rails
Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-11:BC5083-11
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.10303 m2; Volume: 0.00124196 m3
Identity Data - Mark: 33
Other - Family: BC5083-11: BC5083-11; Family and Type: BC5083-11: BC5083-11; Type: BC5083-11: BC5083-11; Type Id: BC5083-11: BC5083-11
Phasing - Phase Created: Phase 1
